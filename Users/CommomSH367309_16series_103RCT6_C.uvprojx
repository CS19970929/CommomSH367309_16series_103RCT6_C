# Keil uVision project CommomSH367309_16series_103RCT6_C.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CommomSH367309_16series_103RCT6_C
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Include;..\Lib;..\STM32F10x_StdPeriph_Lib_V3.5.0\drivers;..\STM32F10x_StdPeriph_Lib_V3.5.0\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004800 size 0x3b000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Include
    ../Include/: ADC.h DataDeal.h EEPROM.h Fault.h Flash.h Heat_Cool.h I2C_AFE1.h LCD.h main.h PubFunc.h RTC.h Sci_Upper.h SleepDeal.h SOC.h System_Init.h System_Monitor.h Uart_Client.h LED_Buzzer.h ProductionID.h Can_HDX.h Cell_balance.h SH367309_Func.h ChargerLoadFunc.h
  group Source
    ../Source/: ADC.c DataDeal.c EEPROM.c Fault.c Flash.c Heat_Cool.c I2C_AFE1.c LCD.c main.c PubFunc.c RTC.c Sci_Upper.c SleepDeal.c SOC.c System_Init.c System_Monitor.c Uart_Client.c LED_Buzzer.c ProductionID.c Can_HDX.c Cell_balance.c SH367309_Func.c ChargerLoadFunc.c SH367309_DataDeal.c LogRecord.c
  group Drivers
    ../STM32F10x_StdPeriph_Lib_V3.5.0/drivers/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group STM32F10x_StdPeriph_Lib_V3.5.0
    ../STM32F10x_StdPeriph_Lib_V3.5.0/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../STM32F10x_StdPeriph_Lib_V3.5.0/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Lib
    ../Lib/: SleepFunction.h SocEnhance.h TestLib.h TestLib.lib SocEnhance.lib SleepFunction.lib
